# IAR project Backup of Rfid_RW_0G_I_DP_Ver1.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151C8 STM8L151C8
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x200
  ICCSTM8.CCDefines: DEBUG; STM8L15X_HD
  ICCSTM8.CCIncludePath2: TAG_MAIN\; TAG_COMMON\; TAG_PROTOCOL\; TAG_CRC\; TAG_IIC\; TAG_GPIO\; TAG_WDT\; TAG_EEMFLASH\; TAG_R3100\; TAG_ZIGBEE\; TAG_RTC\; TAG_SPI\; TAG_TIM1\; TAG_TIM4\; TAG_ADC\; ; STM8L_LIB; STM8L_LIB\inc; TAG_NBIOT\; TAG_UART\; TAG_BT\
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Rfid_RW_R3100_DP_V2.0_0.7.bin
  ILINK.IlinkOutputFile: Rfid_RW_0G_I_DP_Ver1.0.out
  ILINK.IlinkIcfFile: linker\lnkstm8l151c8.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group DOC
    ./: readme.txt
  group SYS_INI
    SYS_INI/: SYSIni.c SYSIni.h
  group SYS_INI/STM8L_LIB
    STM8L_LIB/: stm8l15x_conf.h stm8l15x_it.c stm8l15x_it.h
  group SYS_INI/STM8L_LIB/inc
    STM8L_LIB/inc/: stm8l15x.h stm8l15x_adc.h stm8l15x_aes.h stm8l15x_beep.h stm8l15x_clk.h stm8l15x_comp.h stm8l15x_dac.h stm8l15x_dma.h stm8l15x_exti.h stm8l15x_flash.h stm8l15x_gpio.h stm8l15x_i2c.h stm8l15x_irtim.h stm8l15x_itc.h stm8l15x_iwdg.h stm8l15x_lcd.h stm8l15x_pwr.h stm8l15x_rst.h stm8l15x_rtc.h stm8l15x_spi.h stm8l15x_syscfg.h stm8l15x_tim1.h stm8l15x_tim2.h stm8l15x_tim3.h stm8l15x_tim4.h stm8l15x_tim5.h stm8l15x_usart.h stm8l15x_wfe.h stm8l15x_wwdg.h
  group SYS_INI/STM8L_LIB/src
    STM8L_LIB/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group SYS_INI/TAG_COMMON
    TAG_COMMON/: Common.c Common.h compilefiles.h McuTarger.h MyCommon.c MyCommon.h struct.h Type.h
  group TAG_ADC
    TAG_ADC/: ADCDrv.c ADCDrv.h
  group TAG_BT
    TAG_BT/: Bluetooth.c Bluetooth.h
  group TAG_CRC
    TAG_CRC/: CRC.c CRC.h
  group TAG_EEMFlASH
    TAG_EEMFLASH/: eemFlash.c eemFlash.h
  group TAG_GPIO
    TAG_GPIO/: GPIODrv.c GPIODrv.h
  group TAG_IIC
    TAG_IIC/: Iic.c Iic.h
  group TAG_MAIN
    TAG_MAIN/: main.c main.h
  group TAG_NBIOT
    TAG_NBIOT/: MyNBIOT.c MyNBIOT.h
  group TAG_PROTOCOL
    TAG_PROTOCOL/: protocol.c protocol.h
  group TAG_R3100
    TAG_R3100/: bottomvalAdjustAdaptive.c bottomvalAdjustAdaptive.h common_.h parkStateJudge.c parkStateJudge.h R3100.c R3100.h statisMagneticDensity.c statisMagneticDensity.h
  group TAG_TIM4
    TAG_TIM4/: TIM4Drv.c TIM4Drv.h
  group TAG_UART
    TAG_UART/: UART.c UART.h
  group TAG_WDT
    TAG_WDT/: WDT.c WDT.h
