<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Rfid_RW_0G_I_DP_Ver1.0.ewp</path>
    </project>
    <batchBuild />
</workspace>
